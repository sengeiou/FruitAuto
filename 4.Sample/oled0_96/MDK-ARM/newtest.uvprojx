# Keil uVision project newtest.uvprojx, settings and files
target newtest (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: newtest +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\USER\common;..\USER\led;..\USER\oled0_96
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_tim_ex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Application/User
    ../Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c tim.c gpio.c
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group USER
    ../USER/common/: common.c
    ../USER/led/: led.c
    ../USER/oled0_96/: oled.c
software components: CMSIS:CORE 4.1.0
